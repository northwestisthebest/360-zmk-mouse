## config/360_mouse/Kconfig.defconfig
```kconfig
if SHIELD_360_MOUSE_V1 || SHIELD_360_MOUSE_V2

config ZMK_KEYBOARD_NAME
    default "360 Mouse"

endif
```
